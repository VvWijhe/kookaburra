# Keil uVision project KeilGCCDemo.uvprojx, settings and files
target KeilGCCDemo  (Debug) (ARM-GNU)
  device: STM32F051C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: KeilGCCDemo +hex
  group CMSIS
    ../STM32F0xx_StdPeriph_Lib_V1.5.0/Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
    ../STM32F0xx_StdPeriph_Lib_V1.5.0/Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/gcc_ride7/: startup_stm32f051.s
    ../gcc/: syscalls.c
  group StdPeriphLib
    ../STM32F0xx_StdPeriph_Lib_V1.5.0/Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group CPALv2Lib
    ../STM32F0xx_StdPeriph_Lib_V1.5.0/Libraries/STM32F0xx_CPAL_Driver/src/: stm32f0xx_i2c_cpal.c stm32f0xx_i2c_cpal_hal.c
  group Gemeenschappelijk
    ../STM32_Gemeenschappelijk/source/: stm32f0basis.cpp cpalDriver.c I2Cdev.cpp
  group toepassing
    ../toepassing/: demo.cpp
  group config
    ../STM32_Gemeenschappelijk/config/: stm32f0xx_conf.h stm32f0xx_i2c_cpal_conf.h
target KeilGCCDemo  (Release) (ARM-GNU)
  device: STM32F051C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: as above
  output: KeilGCCDemo +hex
