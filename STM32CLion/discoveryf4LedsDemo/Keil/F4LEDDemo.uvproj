# Keil uVision project F4LEDDemo.uvproj, settings and files
target F4LEDDemo (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: F4LEDDemo
  c flags: Optim=1
  c define: STM32F4xx, USE_STDPERIPH_DRIVER
  c include: ..\h;..\..\gemeenschappelijk\STM32F4Discovery;..\..\gemeenschappelijk\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\gemeenschappelijk\Libraries\STM32F4xx_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Applicatie
    ../: leds.cpp main.cpp
  group CMSIS
    ../../gemeenschappelijk/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../../gemeenschappelijk/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group PerifDriver
    ../../gemeenschappelijk/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group STM32F4Discovery
    ../../gemeenschappelijk/STM32F4Discovery/: Retarget.c stm32f4_discovery.c algdef.cpp stm32Controller.cpp stm32Perifs.cpp
